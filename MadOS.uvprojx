# Keil uVision project MadOS.uvprojx, settings and files
target MadOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MadOS +hex
  c flags: Optim=4
  c define: USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c misc: --feedback=unused.txt
  c include: .\Code\app;.\Code\arch;.\Code\MadOS;.\Code\drivers;.\Code\drivers\ENC28J60;.\Code\lwip;.\Code\lwip\include;.\Code\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --feedback=unused.txt
  group Include
    ./Code/app/: UserConfig.h
  group App
    ./Code/app/: main.c network.c
  group Arch
    ./Code/arch/: MadConfig.h MadArch.h MadArchC.c MadArchS.s ArchMemCpy.c
  group MadOS inc
    ./Code/MadOS/inc/: MadGlobal.h MadMemory.h MadThread.h MadTimeDly.h MadSemaphore.h MadMessage.h MadEvent.h
  group MadOS src
    ./Code/MadOS/: MadOS.h MadMiscTools.h MadGlobal.c MadMemory.c MadThread.c MadTimeDly.c MadSemaphore.c MadMessage.c MadEvent.c
  group Drivers
    ./Code/drivers/: SysInterrupt.c spi_low.c spi_low.h stm32_eval_sdio_sd.c stm32_eval_sdio_sd.h
    ./Code/drivers/ENC28J60/: ENC28J60.c ENC28J60.h ENC28J60_Dev.h
  group lwIP inc
    ./Code/lwip/include/: lwipopts.h
    ./Code/lwip/arch/: sys_arch.h cc.h
    ./Code/lwip/include/lwip/: opt.h sys.h
  group lwIP src
    ./Code/lwip/arch/: sys_arch.c
    ./Code/lwip/api/: sockets.c api_lib.c netbuf.c tcpip.c api_msg.c
    ./Code/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./Code/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./Code/lwip/netif/: etharp.c ethernetif.c
  group FatFs inc
    ./Code/FatFs/: diskio.h ff.h ffconf.h integer.h
  group FatFs src
    ./Code/FatFs/: diskio.c ff.c
  group FatFs option
    ./Code/FatFs/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c syscall.c unicode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
