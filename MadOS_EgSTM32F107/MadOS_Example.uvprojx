# Keil uVision project MadOS_Example.uvprojx, settings and files
target MadOS_EgSTM32F107 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MadOS_Example +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM3210C_EVAL
  c misc: --feedback=unused.txt
  c include: ..\MadOS\Code\arch;..\MadOS\Code\MadOS;..\MadOS\Code\MadLib;..\MadOS\Code\MadLib\pt;..\MadOS\Code\MadLib\timer;.\Code\app;.\Code\arch;.\Code\drivers;.\Code\drivers\ENC28J60;.\Code\LibThirdParty;.\Code\LibThirdParty\uip;.\Code\LibThirdParty\uip-port;.\Code\LibThirdParty\uip-apps
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --feedback=unused.txt
  group Arch
    ../MadOS/Code/arch/: MadConfig.h MadArch.h MadArchC.c MadArchS.s ArchMemCpy.c
  group MadOS
    ../MadOS/Code/MadOS/: MadOS.h MadEvent.c MadFastBuffer.c MadGlobal.c MadMemory.c MadMessage.c MadSemaphore.c MadThread.c MadTimeDly.c
  group MadLib
    ../MadOS/Code/MadLib/timer/: clock-arch.h clock.h timer.h timer.c
    ../MadOS/Code/MadLib/pt/: lc.h lc-addrlabels.h lc-switch.h pt.h
  group Include
    ./Code/app/: UserConfig.h
  group App
    ./Code/app/: main.c Stm32Tools.c testSpiFlash.c testEth.c MadArm.c drv8825.c uln2803a.c
  group Lib-AnsiC
    ./Code/LibAnsiC/: libAnsiC.c
  group Lib-uIP
    ./Code/LibThirdParty/: mod_uIP.h mod_uIP.c
    ./Code/LibThirdParty/uip-port/: uip-conf.h
  group Drivers
    ./Code/drivers/: SysInterrupt.c spi_low.h spi_low.c eth_low.h eth_low_cfg.h eth_low.c stm32_ttyUSART.h stm32_ttyUSART.c stm32_spiFlash.h stm32_spiFlash.c stm32_eth.h stm32_eth.c
  group uIP inc
    ./Code/LibThirdParty/uip/: psock.h uip.h uip_arch.h uip_arp.h uip-fw.h uiplib.h uip-neighbor.h uipopt.h uip-split.h
  group uIP src
    ./Code/LibThirdParty/uip/: psock.c uip.c uip_arp.c uip-fw.c uiplib.c uip-neighbor.c uip-split.c
  group uIP apps
    ./Code/LibThirdParty/uip-apps/: dhcpc.h dhcpc.c resolv.h resolv.c uTcp.h uTcp.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
