# Keil uVision project MadOS.uvprojx, settings and files
target MadOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MadOS +hex
  c flags: Optim=4 uC99=1
  c define: USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c misc: --feedback=unused.txt
  c include: .\Code\app;.\Code\arch;.\Code\MadOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --feedback=unused.txt
  group Include
    ./Code/app/: UserConfig.h
  group App
    ./Code/app/: main.c test.c testMemory.c testMessage.c testEvent.c testFB.c
  group Arch
    ./Code/arch/: MadConfig.h MadArch.h MadArchC.c MadArchS.s ArchMemCpy.c
  group MadOS inc
    ./Code/MadOS/inc/: MadGlobal.h MadMemory.h MadThread.h MadTimeDly.h MadSemaphore.h MadMessage.h MadEvent.h MadFastBuffer.h MadMiscTools.h
  group MadOS src
    ./Code/MadOS/: MadOS.h MadGlobal.c MadMemory.c MadThread.c MadTimeDly.c MadSemaphore.c MadMessage.c MadEvent.c MadFastBuffer.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
