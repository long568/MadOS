# Keil uVision project MadOS_Lua.uvprojx, settings and files
target MadOS_Lua (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MadOS_Lua +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c include: ..\MadOS\Code\arch;..\MadOS\Code\MadOS;..\MadOS_Example\Code\LibAnsiC;..\MadOS_Example\Code\drivers;..\MadOS_Example\Code\drivers\ENC28J60;..\MadOS_Example\Code\FatFs;..\MadOS_Example\Code\FatFs\option;..\MadOS_Example\Code\lwip;..\MadOS_Example\Code\lwip\include;.\Code\app;.\Code\Lua\Lua_src;.\Code\Lua\Lua_if
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Lua inc
    ./Code/Lua/Lua_src/: lapi.h lauxlib.h lcode.h lctype.h ldebug.h ldo.h lfunc.h lgc.h llex.h llimits.h lmem.h lobject.h lopcodes.h lparser.h lprefix.h lstate.h lstring.h ltable.h ltm.h lua.h lualib.h lundump.h lvm.h lzio.h
  group Lua src
    ./Code/Lua/Lua_src/: lauxlib.c ldblib.c loslib.c liolib.c loadlib.c linit.c lapi.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldebug.c ldo.c ldump.c lfunc.c lgc.c llex.c lmathlib.c lmem.c lobject.c lopcodes.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group Lua if
    ./Code/Lua/Lua_src/: luaconf.h lua.c
    ./Code/Lua/Lua_if/: lua_if.h lua_if.c
  group Lua exp
    ./Code/Lua/Lua_src/: luac.c
  group Arch
    ../MadOS/Code/arch/: MadConfig.h MadArch.h MadArchS.s MadArchC.c ArchMemCpy.c
  group MadOS
    ../MadOS/Code/MadOS/: MadOS.h MadEvent.c MadFastBuffer.c MadGlobal.c MadMemory.c MadMessage.c MadSemaphore.c MadThread.c MadTimeDly.c
  group Include
    ./Code/App/: UserConfig.h
  group App
    ./Code/App/: main.c mod_fatfs.c mod_lwip.c mod_lua.c
  group LibAnsiC
    ../MadOS_Example/Code/LibAnsiC/: libAnsiC.c
  group Drivers
    ../MadOS_Example/Code/drivers/ENC28J60/: ENC28J60.c ENC28J60.h ENC28J60_Dev.h ENC28J60_Port.c ENC28J60_Port.h
    ../MadOS_Example/Code/drivers/: spi_low.c spi_low.h stm32_eval_sdio_sd.c stm32_eval_sdio_sd.h stm32_ttyUSART.c stm32_ttyUSART.h SysInterrupt.c
  group LwIP
    ../MadOS_Example/Code/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../MadOS_Example/Code/lwip/arch/: cc.h perf.h sys_arch.c sys_arch.h
    ../MadOS_Example/Code/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../MadOS_Example/Code/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../MadOS_Example/Code/lwip/include/: lwipopts.h
    ../MadOS_Example/Code/lwip/netif/: ethernetif.c etharp.c
  group FatFs
    ../MadOS_Example/Code/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ../MadOS_Example/Code/FatFs/option/: syscall.c unicode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
