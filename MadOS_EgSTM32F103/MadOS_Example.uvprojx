# Keil uVision project MadOS_Example.uvprojx, settings and files
target MadOS_EgSTM32F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MadOS_Example +hex
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, USE_STM3210E_EVAL
  c misc: --feedback=unused.txt
  c include: ..\MadOS\Code\arch;..\MadOS\Code\MadOS;.\Code\app;.\Code\arch;.\Code\drivers;.\Code\drivers\ENC28J60;.\Code\lwip;.\Code\lwip\include;.\Code\FatFs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --feedback=unused.txt
  group Arch
    ../MadOS/Code/arch/: MadConfig.h MadArch.h MadArchC.c MadArchS.s ArchMemCpy.c
  group MadOS
    ../MadOS/Code/MadOS/: MadOS.h MadEvent.c MadFastBuffer.c MadGlobal.c MadMemory.c MadMessage.c MadSemaphore.c MadThread.c MadTimeDly.c
  group Include
    ./Code/app/: UserConfig.h
  group App
    ./Code/app/: main.c mod_lwip.c mod_fatfs.c
  group LibAnsiC
    ./Code/LibAnsiC/: libAnsiC.c
  group Drivers
    ./Code/drivers/: spi_low.c spi_low.h stm32_ttyUSART.c stm32_ttyUSART.h stm32_eval_sdio_sd.c stm32_eval_sdio_sd.h SysInterrupt.c
    ./Code/drivers/ENC28J60/: ENC28J60.c ENC28J60.h ENC28J60_Dev.h ENC28J60_Port.c ENC28J60_Port.h
  group LwIP inc
    ./Code/lwip/include/: lwipopts.h
    ./Code/lwip/arch/: sys_arch.h cc.h
    ./Code/lwip/include/lwip/: opt.h sys.h
  group LwIP src
    ./Code/lwip/arch/: sys_arch.c
    ./Code/lwip/netif/: ethernetif.c etharp.c
    ./Code/lwip/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ./Code/lwip/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ./Code/lwip/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group FatFs inc
    ./Code/FatFs/: ff.h ffconf.h integer.h diskio.h
  group FatFs src
    ./Code/FatFs/: ff.c diskio.c
    ./Code/FatFs/option/: syscall.c unicode.c
  group FatFs opt
    ./Code/FatFs/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c
  group Backup
    ./Code/app/: network.c cloud.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
